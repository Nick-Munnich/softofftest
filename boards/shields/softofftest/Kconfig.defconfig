## boards/shields/softofftest/Kconfig.defconfig
```kconfig
if SHIELD_SOFTOFFTEST

config ZMK_KEYBOARD_NAME
    default "Soft Off Tester"

config ZMK_PM_SOFT_OFF
    def_bool y

endif
```
